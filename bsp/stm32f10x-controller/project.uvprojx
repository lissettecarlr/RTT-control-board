# Keil uVision project project.uvprojx, settings and files
target rtthread-stm32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32F103xE
  c include: .;..\..\..\rt-thread-master\include;applications;.;drivers;Libraries\CMSIS\Device\ST\STM32F1xx\Include;Libraries\STM32F1xx_HAL_Driver\Inc;Libraries\CMSIS\Include;..\..\..\rt-thread-master\libcpu\arm\common;..\..\..\rt-thread-master\libcpu\arm\cortex-m3;..\..\..\rt-thread-master\components\drivers\include;..\..\..\rt-thread-master\components\drivers\include;..\..\..\rt-thread-master\components\drivers\include;..\..\..\rt-thread-master\components\drivers\spi;..\..\..\rt-thread-master\components\drivers\include;..\..\..\rt-thread-master\components\drivers\include;..\..\..\rt-thread-master\components\finsh;..\..\..\rt-thread-master\components\libc\compilers\armlibc;..\..\..\rt-thread-master\components\libc\compilers\common;..\..\..\rt-thread-master\components\net\at\include;..\..\..\rt-thread-master\components\net\freemodbus\modbus\include;..\..\..\rt-thread-master\components\net\freemodbus\modbus\rtu;..\..\..\rt-thread-master\components\net\freemodbus\port;..\..\pck\ulog;..\..\include;..\..\include\libc;..\..\pck\freemodbus\modbus\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Kernel
    ../../Kernel/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
    ./applications/: AT_client_radio.c AT_client_radio.h radio_control.c sensor_control.c
  group Drivers
    drivers/: board.c stm32f1xx_it.c drv_gpio.c drv_usart.c drv_spi.c drv_i2c.c
  group STM32_HAL
    Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_i2c.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_hal.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c stm32f1xx_hal_can.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_i2s.c stm32f1xx_hal_mmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_nand.c stm32f1xx_hal_pccard.c stm32f1xx_hal_nor.c stm32f1xx_hal_sram.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c
    Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../drivers/misc/: pin.c
    ../../drivers/serial/: serial.c
    ../../drivers/spi/: spi_core.c spi_dev.c
    ../../drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../finsh/: cmd.c shell.c symbol.c msh_file.c msh_cmd.c msh.c
  group libc
    ../../libc/compilers/armlibc/: libc.c mem_std.c stubs.c time.c
    ../../libc/compilers/common/: gmtime_r.c
  group AT
    ../../pck/at/src/: at_cli.c at_client.c at_utils.c
  group FreeModbus
    ../../pck/freemodbus/port/: port.c portevent.c portserial.c porttimer.c user_mb_app.c
    ../../pck/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc_m.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../pck/freemodbus/modbus/rtu/: mbcrc.c mbrtu_m.c
    ../../pck/freemodbus/modbus/: mb_m.c
  group sensor
    ../../pck/sensor/light/: light.c
    ../../pck/sensor/pm2_5/: pm2_5.c
    ../../pck/sensor/rain/: rain.c
    ../../pck/sensor/windSpeed/: windSpend.c
    ../../pck/sensor/windDirection/: windDirection.c
  group ulog
    ../../pck/ulog/: ulog.c
    ../../pck/ulog/backend/: console_be.c
